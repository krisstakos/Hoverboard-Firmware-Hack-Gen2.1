# Keil uVision project Hoverboard.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F130C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hoverboard
  AfterMake: D:\Hoverboard-Firmware-Hack-Gen2-master\rename.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Src
    ./Src/: main.c bldc.c setup.c it.c comms.c commsBluetooth.c commsSteering.c commsMasterSlave.c led.c
  group Inc
    ./Inc/: defines.h config.h bldc.h setup.h it.h comms.h commsBluetooth.h commsSteering.h commsMasterSlave.h led.h
software components: CMSIS:CORE 5.5.0, Device:GD32F1x0_StdPeripherals:ADC 3.2.0, Device:GD32F1x0_StdPeripherals:DMA 3.2.0, Device:GD32F1x0_StdPeripherals:FWDGT 3.2.0, Device:GD32F1x0_StdPeripherals:GPIO 3.2.0, Device:GD32F1x0_StdPeripherals:I2C 3.2.0, Device:GD32F1x0_StdPeripherals:MCUDBG 3.2.0, Device:GD32F1x0_StdPeripherals:MISC 3.2.0, Device:GD32F1x0_StdPeripherals:OPA 3.2.0, Device:GD32F1x0_StdPeripherals:PMU 3.2.0, Device:GD32F1x0_StdPeripherals:RCU 3.2.0, Device:GD32F1x0_StdPeripherals:SYSCFG 3.2.0, Device:GD32F1x0_StdPeripherals:TIMER 3.2.0, Device:GD32F1x0_StdPeripherals:USART 3.2.0, Device:GD32F1x0_StdPeripherals:WWDGT 3.2.0, Device:GD32F1x0_libopt 3.2.0, Device:Startup 3.2.0
